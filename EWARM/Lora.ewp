# IAR project Lora.ewp, settings and files
configuration Lora (ARM, debug)
  General.OGChipSelectEditMenu: STM32L071K8 ST STM32L071K8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L071xx; USE_FULL_LL_DRIVER; SELF_ORGANIZING_NETWORK; USE_HAL_DRIVER
  ICCARM.IExtraOptions: -f ..\Common\Tools\loraConfig.cfg; -f ..\Common\Tools\loraConfigLP.cfg
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; D:\Lora\Lora-EnterNet\Radio\sx127x; D:\Lora\Lora-EnterNet\Radio\platform\sx12xxEiger; D:\Lora\Lora-EnterNet\Radio\platform; ..\Network; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ..\Common; ..\Lora; ..\OS; ..\Mac; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: Lora.hex
  ILINK.IlinkOutputFile: Lora.out
  ILINK.IlinkIcfFile: stm32l071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Lora_lowPower (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L071xx; USE_FULL_LL_DRIVER; SELF_ORGANIZING_NETWORK
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\Radio\sx127x; ..\Radio\platform\sx12xxEiger; ..\Radio\platform; ..\Network; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ..\Common; ..\Lora; ..\OS; ..\Mac; ..\Zigbee
  group Application/EWARM
    ./: startup_stm32l071xx.s
  group Application/User
    ../Src/: dma.c freertos.c gpio.c iwdg.c main.c spi.c stm32l0xx_hal_msp.c stm32l0xx_it.c usart.c main.c gpio.c dma.c freertos.c iwdg.c spi.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Common
    ../Common/: loraConfig.h
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
    ..//Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_rcc.c stm32l0xx_ll_spi.c stm32l0xx_ll_utils.c stm32l0xx_ll_gpio.c stm32l0xx_ll_spi.c stm32l0xx_ll_dma.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
  group Lora
    ../Lora/: lora.c lora.h lora_driver.c lora_driver.h
  group Mac
    ../Mac/: security.c security.h transmit.c transmit.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s port.c portasm.s
  group Network
    ../Network/: attribute.c attribute.h Network.c Network.h NwkConfig.c NwkConfig.h
  group OS
    ../OS/: OS_flash.c OS_flash.h OS_timers.c OS_timers.h OStask.c OStask.h
  group Radio
    ../Radio/platform/sx12xxEiger/: fifo.c sx1276-Hal.c sx12xxEiger.c
    ../Radio/sx127x/: radio.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276.c
  group Tools
    ../Common/Tools/: loraConfig.cfg loraConfigLP.cfg
  group Zigbee
    ../Zigbee/: zigbee.c zigbee.h
